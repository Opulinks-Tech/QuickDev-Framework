# Keil uVision project at_slave.uvprojx, settings and files
target AT_SLAVE_TCP (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: at_slave_tcp_m3 +hex
  AfterMake: .\at_slave.bat $L @L $K
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OPL2500_APS OPL2500_PATCH __noSIMULATOR__ __BLE__ __LE_HOST_USE_CMD__ __LWIP_TASK__ __WIFI_MAC_TASK__ __PMP_ENABLE__ __PMP_REGION__ __HEAP_REGION__ noLWIP_DYNAMIC_DEBUG_ENABLE __AT_CMD_TASK__ __noRTL_SIMULATION__ MBEDTLS_CONFIG_FILE="<config-opl-default.h>" OPL2500_A0 HOST_MODE_TCP
  c misc: --preinclude=sys_common.h
  c include: ..\..\..\..\sdk\SDK\APS\project\opl2500\boot_sequence;..\..\..\..\sdk\SDK\APS\project\opl2500\include;..\..\..\..\sdk\SDK\APS\project\opl2500\lib;..\..\..\..\sdk\SDK\APS\project\opl2500\startup;..\..\..\..\sdk\SDK\APS\project\common;..\..\..\..\sdk\SDK\APS\FreeRtos;..\..\..\..\sdk\SDK\APS\FreeRtos\Source\include;..\..\..\..\sdk\SDK\APS\FreeRtos\Source\portable\Keil\ARM_CM4F;..\..\..\..\sdk\SDK\APS\driver\CMSIS\Device\Opulinks\opl2500\Include;..\..\..\..\sdk\SDK\APS\driver\CMSIS\Include;..\..\..\..\sdk\SDK\APS\driver\chip;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\camera;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_auxadc;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_dbg_uart;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_dma;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_gpio;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_i2c;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_patch;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_pdm;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_pwm;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_spi;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_system;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_tick;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_tmr;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_uart;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_vic;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_wdt;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\securityipdriver;..\..\..\..\sdk\SDK\APS\middleware\netlink;..\..\..\..\sdk\SDK\APS\middleware\netlink\at;..\..\..\..\sdk\SDK\APS\middleware\netlink\ble_controller_layer\inc;..\..\..\..\sdk\SDK\APS\middleware\netlink\cli;..\..\..\..\sdk\SDK\APS\middleware\netlink\common\sys_api;..\..\..\..\sdk\SDK\APS\middleware\netlink\common\sys_api\rom_if;..\..\..\..\sdk\SDK\APS\middleware\netlink\common\sys_ctrl;..\..\..\..\sdk\SDK\APS\middleware\netlink\controller_task;..\..\..\..\sdk\SDK\APS\middleware\netlink\data_flow;..\..\..\..\sdk\SDK\APS\middleware\netlink\diag_task;..\..\..\..\sdk\SDK\APS\middleware\netlink\le_stack;..\..\..\..\sdk\SDK\APS\middleware\netlink\msg;..\..\..\..\sdk\SDK\APS\middleware\netlink\mw_fim;..\..\..\..\sdk\SDK\APS\middleware\netlink\mw_ota;..\..\..\..\sdk\SDK\APS\middleware\netlink\ps_task;..\..\..\..\sdk\SDK\APS\middleware\netlink\wifi_controller_layer;..\..\..\..\sdk\SDK\APS\middleware\netlink\wifi_mac;..\..\..\..\sdk\SDK\APS\middleware\netlink\wifi_mac\utils;..\..\..\..\sdk\SDK\APS\middleware\netlink\wifi_mac\common;..\..\..\..\sdk\SDK\APS\middleware\third_party\httpclient;..\..\..\..\sdk\SDK\APS\middleware\third_party\lwip-2.0.3;..\..\..\..\sdk\SDK\APS\middleware\third_party\lwip-2.0.3\lwip\src\include;..\..\..\..\sdk\SDK\APS\middleware\third_party\lwip-2.0.3\lwip\src\include\lwip;..\..\..\..\sdk\SDK\APS\middleware\third_party\lwip-2.0.3\ports\freertos\include;..\..\..\..\sdk\SDK\APS\middleware\third_party\lwip-2.0.3\ports\freertos\netif;..\..\..\..\sdk\SDK\APS\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\..\..\sdk\SDK\APS\middleware\third_party\lwip-2.0.3\contrib\apps;..\..\..\..\sdk\SDK\APS\middleware\third_party\mbedtls\configs;..\..\..\..\sdk\SDK\APS\middleware\third_party\mbedtls\include;..\..\..\..\sdk\SDK\APS\middleware\third_party\mbedtls\include\mbedtls;..\..\..\..\sdk\SDK\APS\middleware\third_party\mbedtls\port\include;..\..\..\..\sdk\SDK\APS\middleware\third_party\tinycrypt\include;..\..\..\..\sdk\SDK\APS\middleware\third_party\tinycrypt\include\tinycrypt;..\..\..\..\sdk\SDK\APS\apps\le_app\cmd_app;..\..\..\..\sdk\SDK\APS\apps\le_app\pts_app;..\..\..\..\sdk\SDK\APS_PATCH\project\opl2500\boot_sequence;..\..\..\..\sdk\SDK\APS_PATCH\project\opl2500\include;..\..\..\..\sdk\SDK\APS_PATCH\project\opl2500\lib;..\..\..\..\sdk\SDK\APS_PATCH\project\opl2500\startup;..\..\..\..\sdk\SDK\APS_PATCH\project\common;..\..\..\..\sdk\SDK\APS_PATCH\FreeRtos;..\..\..\..\sdk\SDK\APS_PATCH\FreeRtos\Source\include;..\..\..\..\sdk\SDK\APS_PATCH\FreeRtos\Source\portable\Keil\ARM_CM4F;..\..\..\..\sdk\SDK\APS_PATCH\driver\CMSIS\Device\Opulinks\opl2500\Include;..\..\..\..\sdk\SDK\APS_PATCH\driver\CMSIS\Include;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\camera;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_auxadc;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_dbg_uart;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_dma;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_gpio;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_i2c;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_patch;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_pdm;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_pwm;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_spi;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_system;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_tick;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_tmr;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_uart;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_vic;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_wdt;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\securityipdriver;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\at;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\ble_controller_layer\inc;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\cli;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\common\sys_api;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\common\sys_api\rom_if;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\common\sys_ctrl;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\controller_task;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\data_flow;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\diag_task;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\le_stack;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\msg;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\mw_fim;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\mw_ota;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\ps_task;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\wifi_controller_layer;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\wifi_mac;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\wifi_mac\common;..\..\..\..\sdk\SDK\APS_PATCH\middleware\third_party\lwip-2.0.3;..\..\..\..\sdk\SDK\APS_PATCH\middleware\third_party\lwip-2.0.3\lwip\src\include;..\..\..\..\sdk\SDK\APS_PATCH\middleware\third_party\lwip-2.0.3\ports\freertos\include;..\..\..\..\sdk\SDK\APS_PATCH\middleware\third_party\lwip-2.0.3\ports\freertos\netif;..\..\..\..\sdk\SDK\APS_PATCH\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\..\..\sdk\SDK\APS_PATCH\middleware\third_party\lwip-2.0.3\contrib\apps;..\..\..\..\sdk\SDK\APS_PATCH\middleware\third_party\mbedtls\configs;..\..\..\..\sdk\SDK\APS_PATCH\middleware\third_party\mbedtls\include;..\..\..\..\sdk\SDK\APS_PATCH\middleware\third_party\mbedtls\include\mbedtls;..\..\..\..\sdk\SDK\APS_PATCH\middleware\third_party\mbedtls\port\include;..\..\..\..\sdk\SDK\APS_PATCH\middleware\third_party\tinycrypt\include;..\..\..\..\sdk\SDK\APS_PATCH\middleware\third_party\tinycrypt\include\tinycrypt;..\..\..\..\sdk\SDK\APS_PATCH\apps\le_app\cmd_app;..\..\..\..\sdk\SDK\APS_PATCH\apps\le_app\include;..\..\..\..\sdk\SDK\APS_PATCH\apps\le_app\pts_app;..\..\..\..\quick_dev;..\..\..\..\quick_dev\app_ref\ble_data_prot\opl_data;..\..\..\..\quick_dev\app_ref\ble_services;..\..\..\..\quick_dev\app_ref\cloud;..\..\..\..\quick_dev\app_ref\cloud\tcp_cloud;..\..\..\..\quick_dev\app_ref\cloud\tcp_cloud\infra_cjson;..\..\..\..\quick_dev\app_ref\cloud\tcp_cloud\tcp_client;..\..\..\..\quick_dev\app_ref\mngr_api\ble_mngr_api;..\..\..\..\quick_dev\app_ref\mngr_api\net_mngr_api;..\..\..\..\quick_dev\app_ref\mngr_api\wifi_mngr_api;..\..\..\..\quick_dev\common\battery;..\..\..\..\quick_dev\common\config\ps_config;..\..\..\..\quick_dev\common\error;..\..\..\..\quick_dev\common\evt_group;..\..\..\..\quick_dev\common\fsm;..\..\..\..\quick_dev\common\httpclient_exp;..\..\..\..\quick_dev\common\log;..\..\..\..\quick_dev\common\mp;..\..\..\..\quick_dev\common\ota;..\..\..\..\quick_dev\common\pwr_save;..\..\..\..\quick_dev\common\rf_pwr;..\..\..\..\quick_dev\common\ring_buffer;..\..\..\..\quick_dev\common\time_stmp;..\..\..\..\quick_dev\middleware\ble_mngr;..\..\..\..\quick_dev\middleware\net_mngr;..\..\..\..\quick_dev\middleware\wifi_mngr;..\..\..\..\quick_dev\middleware\wifi_mngr\wifi_autocon;..\..\..\..\quick_dev\middleware\wifi_mngr\wifi_agent;..\..\..\..\quick_dev\middleware\wifi_mngr\wifi_pro_rec;..\main;..\main\hal;..\main\sys_config;.\hal;.\board
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\at_slave.sct
  link misc: --datacompressor off --any_contingency --entry=__Patch_EntryPoint
  group main
    ../main/: app_main.c app_at_cmd.c
  group hal
    ./hal/: main_patch.c
    ../../../../quick_dev/middleware/wifi_mngr/wifi_pro_rec/: mw_fim_default_group11_project.c
    ../../../../quick_dev/common/mp/: mw_fim_default_group12_project.c
    ../../../../quick_dev/common/battery/: mw_fim_default_group16_project.c
  group board
    ./board/: hal_pin_config_project.h
  group sys_config
    ../main/sys_config/: qd_config.h qd_module.h
  group object
    ../../../../sdk/SDK/APS/targets/opl2500/object/: symdefs.o
    ../../../../sdk/SDK/APS/targets/opl2500/Output/Objects/: opl2500_patch_aps.lib opl2500_sdk_aps.lib
  group net_mngr
    ../../../../quick_dev/middleware/net_mngr/: net_mngr.c net_mngr_api.c net_mngr_at.c
  group wifi_mngr
    ../../../../quick_dev/middleware/wifi_mngr/: wifi_mngr.c wifi_mngr_api.c wifi_mngr_at.c
    ../../../../quick_dev/middleware/wifi_mngr/wifi_agent/: wifi_agent.c wifi_agent_api.c
    ../../../../quick_dev/middleware/wifi_mngr/wifi_autocon/: wifi_autocon.c wifi_autocon_at.c
    ../../../../quick_dev/middleware/wifi_mngr/wifi_pro_rec/: wifi_pro_rec.c
  group ble_mngr
    ../../../../quick_dev/middleware/ble_mngr/: ble_mngr.c ble_mngr_api.c ble_mngr_at.c
  group ble_services
    ../../../../quick_dev/app_ref/ble_services/: gap_svc.c gatt_svc.c
  group common
    ../../../../quick_dev/common/battery/: bat_aux.c
    ../../../../quick_dev/common/evt_group/: evt_group.c
    ../../../../quick_dev/common/fsm/: fsm_kernel.c
    ../../../../quick_dev/common/log/: log.c
    ../../../../quick_dev/common/error/: opl_err.h
    ../../../../quick_dev/common/ota/: ota_mngr.c
    ../../../../quick_dev/common/pwr_save/: pwr_save.c
    ../../../../quick_dev/common/rf_pwr/: rf_pwr.c
  group opl_data
    ../../../../quick_dev/app_ref/ble_data_prot/opl_data/: opl_data_hdl.c opl_data_prot.c opl_svc.c
  group tcp_cloud
    ../../../../quick_dev/app_ref/cloud/tcp_cloud/: cloud_ctrl.c cloud_data.c cloud_kernel.c
    ../../../../quick_dev/app_ref/cloud/tcp_cloud/infra_cjson/: infra_cjson.c
    ../../../../quick_dev/app_ref/cloud/tcp_cloud/tcp_client/: tcp_client.c
  group mqtt_cloud
    ../../../../quick_dev/app_ref/cloud/mqtt_cloud/: cloud_ctrl.c cloud_data.c cloud_kernel.c
  group aws_iot_src
    ../../../../quick_dev/app_ref/cloud/mqtt_cloud/aws-iot-device-sdk-embedded-C-3.0.1/src/: aws_iot_mqtt_client_connect.c aws_iot_mqtt_client.c aws_iot_json_utils.c aws_iot_mqtt_client_common_internal.c aws_iot_mqtt_client_publish.c aws_iot_mqtt_client_subscribe.c aws_iot_mqtt_client_unsubscribe.c aws_iot_mqtt_client_yield.c
    ../../../../quick_dev/app_ref/cloud/mqtt_cloud/aws-iot-device-sdk-embedded-C-3.0.1/platform/linux/common/: timer.c
    ../../../../quick_dev/app_ref/cloud/mqtt_cloud/aws-iot-device-sdk-embedded-C-3.0.1/platform/linux/mbedtls/: network_mbedtls_wrapper.c
    ../../../../quick_dev/app_ref/cloud/mqtt_cloud/aws-iot-device-sdk-embedded-C-3.0.1/external_libs/jsmn/: jsmn.c
    ../../../../quick_dev/app_ref/cloud/mqtt_cloud/aws-iot-device-sdk-embedded-C-3.0.1/platform/linux/pthread/: threads_pthread_wrapper.c
target AT_SLAVE_MQTT (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: at_slave_mqtt_m3 +hex
  AfterMake: .\at_slave.bat $L @L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OPL2500_APS OPL2500_PATCH __noSIMULATOR__ __BLE__ __LE_HOST_USE_CMD__ __LWIP_TASK__ __WIFI_MAC_TASK__ __PMP_ENABLE__ __PMP_REGION__ __HEAP_REGION__ noLWIP_DYNAMIC_DEBUG_ENABLE __AT_CMD_TASK__ __noRTL_SIMULATION__ MBEDTLS_CONFIG_FILE="<config-opl-default.h>" OPL2500_A0 HOST_MODE_MQTT _ENABLE_THREAD_SUPPORT_
  c misc: --preinclude=sys_common.h
  c include: ..\..\..\..\sdk\SDK\APS\project\opl2500\boot_sequence;..\..\..\..\sdk\SDK\APS\project\opl2500\include;..\..\..\..\sdk\SDK\APS\project\opl2500\lib;..\..\..\..\sdk\SDK\APS\project\opl2500\startup;..\..\..\..\sdk\SDK\APS\project\common;..\..\..\..\sdk\SDK\APS\FreeRtos;..\..\..\..\sdk\SDK\APS\FreeRtos\Source\include;..\..\..\..\sdk\SDK\APS\FreeRtos\Source\portable\Keil\ARM_CM4F;..\..\..\..\sdk\SDK\APS\driver\CMSIS\Device\Opulinks\opl2500\Include;..\..\..\..\sdk\SDK\APS\driver\CMSIS\Include;..\..\..\..\sdk\SDK\APS\driver\chip;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\camera;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_auxadc;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_dbg_uart;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_dma;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_gpio;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_i2c;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_patch;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_pdm;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_pwm;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_spi;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_system;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_tick;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_tmr;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_uart;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_vic;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\hal_wdt;..\..\..\..\sdk\SDK\APS\driver\chip\opl2500\securityipdriver;..\..\..\..\sdk\SDK\APS\middleware\netlink;..\..\..\..\sdk\SDK\APS\middleware\netlink\at;..\..\..\..\sdk\SDK\APS\middleware\netlink\ble_controller_layer\inc;..\..\..\..\sdk\SDK\APS\middleware\netlink\cli;..\..\..\..\sdk\SDK\APS\middleware\netlink\common\sys_api;..\..\..\..\sdk\SDK\APS\middleware\netlink\common\sys_api\rom_if;..\..\..\..\sdk\SDK\APS\middleware\netlink\common\sys_ctrl;..\..\..\..\sdk\SDK\APS\middleware\netlink\controller_task;..\..\..\..\sdk\SDK\APS\middleware\netlink\data_flow;..\..\..\..\sdk\SDK\APS\middleware\netlink\diag_task;..\..\..\..\sdk\SDK\APS\middleware\netlink\le_stack;..\..\..\..\sdk\SDK\APS\middleware\netlink\msg;..\..\..\..\sdk\SDK\APS\middleware\netlink\mw_fim;..\..\..\..\sdk\SDK\APS\middleware\netlink\mw_ota;..\..\..\..\sdk\SDK\APS\middleware\netlink\ps_task;..\..\..\..\sdk\SDK\APS\middleware\netlink\wifi_controller_layer;..\..\..\..\sdk\SDK\APS\middleware\netlink\wifi_mac;..\..\..\..\sdk\SDK\APS\middleware\netlink\wifi_mac\utils;..\..\..\..\sdk\SDK\APS\middleware\netlink\wifi_mac\common;..\..\..\..\sdk\SDK\APS\middleware\third_party\httpclient;..\..\..\..\sdk\SDK\APS\middleware\third_party\lwip-2.0.3;..\..\..\..\sdk\SDK\APS\middleware\third_party\lwip-2.0.3\lwip\src\include;..\..\..\..\sdk\SDK\APS\middleware\third_party\lwip-2.0.3\lwip\src\include\lwip;..\..\..\..\sdk\SDK\APS\middleware\third_party\lwip-2.0.3\ports\freertos\include;..\..\..\..\sdk\SDK\APS\middleware\third_party\lwip-2.0.3\ports\freertos\netif;..\..\..\..\sdk\SDK\APS\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\..\..\sdk\SDK\APS\middleware\third_party\lwip-2.0.3\contrib\apps;..\..\..\..\sdk\SDK\APS\middleware\third_party\mbedtls\configs;..\..\..\..\sdk\SDK\APS\middleware\third_party\mbedtls\include;..\..\..\..\sdk\SDK\APS\middleware\third_party\mbedtls\include\mbedtls;..\..\..\..\sdk\SDK\APS\middleware\third_party\mbedtls\port\include;..\..\..\..\sdk\SDK\APS\middleware\third_party\tinycrypt\include;..\..\..\..\sdk\SDK\APS\middleware\third_party\tinycrypt\include\tinycrypt;..\..\..\..\sdk\SDK\APS\apps\le_app\cmd_app;..\..\..\..\sdk\SDK\APS\apps\le_app\pts_app;..\..\..\..\sdk\SDK\APS_PATCH\project\opl2500\boot_sequence;..\..\..\..\sdk\SDK\APS_PATCH\project\opl2500\include;..\..\..\..\sdk\SDK\APS_PATCH\project\opl2500\lib;..\..\..\..\sdk\SDK\APS_PATCH\project\opl2500\startup;..\..\..\..\sdk\SDK\APS_PATCH\project\common;..\..\..\..\sdk\SDK\APS_PATCH\FreeRtos;..\..\..\..\sdk\SDK\APS_PATCH\FreeRtos\Source\include;..\..\..\..\sdk\SDK\APS_PATCH\FreeRtos\Source\portable\Keil\ARM_CM4F;..\..\..\..\sdk\SDK\APS_PATCH\driver\CMSIS\Device\Opulinks\opl2500\Include;..\..\..\..\sdk\SDK\APS_PATCH\driver\CMSIS\Include;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\camera;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_auxadc;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_dbg_uart;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_dma;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_gpio;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_i2c;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_patch;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_pdm;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_pwm;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_spi;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_system;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_tick;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_tmr;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_uart;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_vic;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\hal_wdt;..\..\..\..\sdk\SDK\APS_PATCH\driver\chip\opl2500\securityipdriver;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\at;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\ble_controller_layer\inc;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\cli;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\common\sys_api;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\common\sys_api\rom_if;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\common\sys_ctrl;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\controller_task;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\data_flow;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\diag_task;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\le_stack;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\msg;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\mw_fim;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\mw_ota;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\ps_task;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\wifi_controller_layer;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\wifi_mac;..\..\..\..\sdk\SDK\APS_PATCH\middleware\netlink\wifi_mac\common;..\..\..\..\sdk\SDK\APS_PATCH\middleware\third_party\lwip-2.0.3;..\..\..\..\sdk\SDK\APS_PATCH\middleware\third_party\lwip-2.0.3\lwip\src\include;..\..\..\..\sdk\SDK\APS_PATCH\middleware\third_party\lwip-2.0.3\ports\freertos\include;..\..\..\..\sdk\SDK\APS_PATCH\middleware\third_party\lwip-2.0.3\ports\freertos\netif;..\..\..\..\sdk\SDK\APS_PATCH\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\..\..\sdk\SDK\APS_PATCH\middleware\third_party\lwip-2.0.3\contrib\apps;..\..\..\..\sdk\SDK\APS_PATCH\middleware\third_party\mbedtls\configs;..\..\..\..\sdk\SDK\APS_PATCH\middleware\third_party\mbedtls\include;..\..\..\..\sdk\SDK\APS_PATCH\middleware\third_party\mbedtls\include\mbedtls;..\..\..\..\sdk\SDK\APS_PATCH\middleware\third_party\mbedtls\port\include;..\..\..\..\sdk\SDK\APS_PATCH\middleware\third_party\tinycrypt\include;..\..\..\..\sdk\SDK\APS_PATCH\middleware\third_party\tinycrypt\include\tinycrypt;..\..\..\..\sdk\SDK\APS_PATCH\apps\le_app\cmd_app;..\..\..\..\sdk\SDK\APS_PATCH\apps\le_app\include;..\..\..\..\sdk\SDK\APS_PATCH\apps\le_app\pts_app;..\..\..\..\quick_dev;..\..\..\..\quick_dev\app_ref\ble_data_prot\opl_data;..\..\..\..\quick_dev\app_ref\ble_services;..\..\..\..\quick_dev\app_ref\cloud;..\..\..\..\quick_dev\app_ref\cloud\mqtt_cloud;..\..\..\..\quick_dev\app_ref\cloud\mqtt_cloud\aws-iot-device-sdk-embedded-C-3.0.1\include;..\..\..\..\quick_dev\app_ref\cloud\mqtt_cloud\aws-iot-device-sdk-embedded-C-3.0.1\platform\linux;..\..\..\..\quick_dev\app_ref\cloud\mqtt_cloud\aws-iot-device-sdk-embedded-C-3.0.1\platform\linux\common;..\..\..\..\quick_dev\app_ref\cloud\mqtt_cloud\aws-iot-device-sdk-embedded-C-3.0.1\platform\linux\mbedtls;..\..\..\..\quick_dev\app_ref\cloud\mqtt_cloud\aws-iot-device-sdk-embedded-C-3.0.1\platform\linux\pthread;..\..\..\..\quick_dev\app_ref\cloud\mqtt_cloud\aws-iot-device-sdk-embedded-C-3.0.1\external_libs\jsmn;..\..\..\..\quick_dev\app_ref\mngr_api\ble_mngr_api;..\..\..\..\quick_dev\app_ref\mngr_api\net_mngr_api;..\..\..\..\quick_dev\app_ref\mngr_api\wifi_mngr_api;..\..\..\..\quick_dev\common\battery;..\..\..\..\quick_dev\common\config\ps_config;..\..\..\..\quick_dev\common\error;..\..\..\..\quick_dev\common\evt_group;..\..\..\..\quick_dev\common\fsm;..\..\..\..\quick_dev\common\httpclient_exp;..\..\..\..\quick_dev\common\log;..\..\..\..\quick_dev\common\mp;..\..\..\..\quick_dev\common\ota;..\..\..\..\quick_dev\common\pwr_save;..\..\..\..\quick_dev\common\rf_pwr;..\..\..\..\quick_dev\common\ring_buffer;..\..\..\..\quick_dev\common\time_stmp;..\..\..\..\quick_dev\middleware\ble_mngr;..\..\..\..\quick_dev\middleware\net_mngr;..\..\..\..\quick_dev\middleware\wifi_mngr;..\..\..\..\quick_dev\middleware\wifi_mngr\wifi_autocon;..\..\..\..\quick_dev\middleware\wifi_mngr\wifi_agent;..\..\..\..\quick_dev\middleware\wifi_mngr\wifi_pro_rec;..\main;..\main\hal;..\main\sys_config;.\hal;.\board
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\at_slave.sct
  link misc: as above
